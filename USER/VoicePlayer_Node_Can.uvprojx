# Keil uVision project VoicePlayer_Node_Can.uvprojx, settings and files
target VoicePlayer_Node_Can (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\GPIO;..\HARDWARE\IWDG;..\HARDWARE\TIME;..\HARDWARE\USART2;..\HARDWARE\JQ8X00
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c sys_config.h VersionInformation.c VersionInformation.h
  group HARDWARE
    ../HARDWARE/USART2/: usart2.c usart2.h
    ../HARDWARE/ADC/: adc.h adc.c
    ../HARDWARE/CAN/: can.c can.h
    ../HARDWARE/GPIO/: gpio.c gpio.h
    ../HARDWARE/IWDG/: iwdg.c iwdg.h
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIME/: time.c time.h
    ../HARDWARE/JQ8X00/: JQ8X00.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
